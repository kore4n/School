# Keil uVision project LabSix.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: LabSix
  c flags: Optim=1
  group Source Group 1
    ./: Assembly_Lab_6_1d.s Assembly_Lab_6_2b.s
